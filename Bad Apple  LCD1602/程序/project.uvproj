# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Library\Time;.\Library\Delay;.\Library\LCD1602;.\Library\UART
  group Source Group 1
    ./: main.c
  group Library
    ./Library/Time/: Time.c
    ./Library/Delay/: Delay.c
    ./Library/LCD1602/: LCD1602.c
    ./Library/UART/: UART.c
